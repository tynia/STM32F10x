# Keil uVision project STM32F10x.uvproj, settings and files
target STM32F10x (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10x +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,_DEBUG
  c include: .\core;.\fwlib;.\system;.\user;.\utilities;.\rtx\inc;.\rtx\portable;.\json
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ./system/: stm32f10x_it.c system_stm32f10x.c
  group user
    ./user/at/: aithinker_a6.c
    ./user/buffer/: buffer.c
    ./user/debug/: debug.c debugger.c
    ./user/gpio/: gpio.c
    ./user/led/: led.c
    ./user/nvic/: nvic.c
    ./user/rcc/: rcc.c
    ./user/usart/: irq_usart_handler.c usart.c
    ./user/util/: util.c
    ./user/: main.c
    ./user/transfer/: transfer.c
    ./user/acceptor/: acceptor.c
    ./user/allocator/: allocator.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group utilities
    ./utilities/: stm32_eval.c stm3210e_eval_lcd.c
  group rtx
    ./rtx/: RTX_Conf_CM.c
  group json
    ./json/: cJSON.c
